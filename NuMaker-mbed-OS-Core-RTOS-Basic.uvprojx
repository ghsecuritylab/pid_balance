# Keil uVision project NuMaker-mbed-OS-Core-RTOS-Basic.uvprojx, settings and files
target NuMaker-mbed-OS-Core-RTOS-Basic (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: NuMaker-mbed-OS-Core-RTOS-Basic
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEVICE_RTC=1 DEVICE_SLEEP=1 ARM_MATH_CM4 MBEDTLS_CONFIG_HW_SUPPORT FEATURE_LWIP=1 TARGET_NAME=NUMAKER_PFM_M487 __ASSERT_MSG TARGET_NUVOTON DEVICE_PORTINOUT=1 DEVICE_I2C_ASYNCH=1 TARGET_RTOS_M4_M7 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_FLASH=1 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE TARGET_LIKE_MBED DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M MBED_BUILD_TIMESTAMP=1567611249.9 DEVICE_I2C=1 __CORTEX_M4 TARGET_CORTEX TARGET_M480 DEVICE_LOWPOWERTIMER=1 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TARGET_FLASH_CMSIS_ALGO TOOLCHAIN_ARM_STD DEVICE_PWMOUT=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_TRNG=1 DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TARGET_NUMAKER_PFM_M487 __MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --no_depend_system_headers --md --gnu --apcs=interwork --cpu=Cortex-M4.fp.sp --preinclude=mbed_config.h
  c include: /usr/src/mbed-sdk;mbed-os;mbed-os/cmsis/TARGET_CORTEX_M;mbed-os/drivers;mbed-os/events;mbed-os/events/equeue;mbed-os/features;mbed-os/features/FEATURE_LWIP;mbed-os/features/FEATURE_LWIP/lwip-interface;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_NUVOTON/TARGET_M480;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp;mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl;mbed-os/features/cellular;mbed-os/features/cellular/easy_cellular;mbed-os/features/cellular/framework;mbed-os/features/cellular/framework/API;mbed-os/features/cellular/framework/AT;mbed-os/features/cellular/framework/common;mbed-os/features/cellular/framework/targets;mbed-os/features/cellular/framework/targets/QUECTEL;mbed-os/features/cellular/framework/targets/QUECTEL/BC95;mbed-os/features/cellular/framework/targets/QUECTEL/BG96;mbed-os/features/cellular/framework/targets/TELIT;mbed-os/features/cellular/framework/targets/TELIT/HE910;mbed-os/features/cellular/framework/targets/UBLOX;mbed-os/features/cellular/framework/targets/UBLOX/LISA_U;mbed-os/features/filesystem;mbed-os/features/filesystem/bd;mbed-os/features/filesystem/fat;mbed-os/features/filesystem/fat/ChaN;mbed-os/features/filesystem/littlefs;mbed-os/features/filesystem/littlefs/littlefs;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/utest;mbed-os/features/lorawan;mbed-os/features/lorawan/lorastack;mbed-os/features/lorawan/lorastack/mac;mbed-os/features/lorawan/lorastack/phy;mbed-os/features/lorawan/system;mbed-os/features/mbedtls;mbed-os/features/mbedtls/inc;mbed-os/features/mbedtls/inc/mbedtls;mbed-os/features/mbedtls/platform;mbed-os/features/mbedtls/platform/inc;mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480;mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/TARGET_NUMAKER_PFM_M487;mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/aes;mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/des;mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/sha;mbed-os/features/netsocket;mbed-os/features/netsocket/cellular;mbed-os/features/netsocket/cellular/generic_modem_driver;mbed-os/features/nvstore;mbed-os/features/nvstore/source;mbed-os/hal;mbed-os/hal/TARGET_FLASH_CMSIS_ALGO;mbed-os/hal/storage_abstraction;mbed-os/platform;mbed-os/rtos;mbed-os/rtos/TARGET_CORTEX;mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M;mbed-os/rtos/TARGET_CORTEX/rtx4;mbed-os/rtos/TARGET_CORTEX/rtx5;mbed-os/rtos/TARGET_CORTEX/rtx5/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include;mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source;mbed-os/targets/TARGET_NUVOTON;mbed-os/targets/TARGET_NUVOTON/TARGET_M480;mbed-os/targets/TARGET_NUVOTON/TARGET_M480/TARGET_NUMAKER_PFM_M487;mbed-os/targets/TARGET_NUVOTON/TARGET_M480/crypto;mbed-os/targets/TARGET_NUVOTON/TARGET_M480/device;mbed-os/targets/TARGET_NUVOTON/TARGET_M480/device/StdDriver
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DMBEDTLS_CONFIG_HW_SUPPORT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .link_script.sct
  link misc: --show_full_path --keep=os_cb_sections
  group mbed-os
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/aes/: aes_alt.c aes_alt.h
    mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/: analogin_api.c can_api.c dma.h dma_api.c flash_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c trng_api.c us_ticker.c
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical_section_api.h dma_api.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h lwip_errno.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
    mbed-os/features/cellular/easy_cellular/: APN_db.h CellularConnectionFSM.cpp CellularConnectionFSM.h EasyCellularConnection.cpp EasyCellularConnection.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed-os/features/cellular/framework/AT/: AT_CellularBase.cpp AT_CellularBase.h AT_CellularDevice.cpp AT_CellularDevice.h AT_CellularInformation.cpp AT_CellularInformation.h AT_CellularNetwork.cpp AT_CellularNetwork.h AT_CellularPower.cpp AT_CellularPower.h AT_CellularSIM.cpp AT_CellularSIM.h AT_CellularSMS.cpp AT_CellularSMS.h AT_CellularStack.cpp AT_CellularStack.h ATHandler.cpp ATHandler.h
    mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h lwip_ethernet.h mld6.h nd6.h tcp.h udp.h
    mbed-os/features/filesystem/bd/: BlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    mbed-os/features/netsocket/: CellularBase.h CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    mbed-os/features/cellular/framework/common/: CellularList.h CellularLog.h CellularTargets.h CellularUtil.cpp CellularUtil.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/device/: cmsis.h cmsis_nvic.h M480.h startup_M480.c system_M480.c system_M480.h
    mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/crypto/: crypto-misc.c crypto-misc.h
    mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/des/: des_alt.c des_alt.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/TARGET_NUMAKER_PFM_M487/: device.h mbed_overrides.c objects.h PeripheralNames.h PeripheralPins.c PeripheralPins.h PinNames.h PortNames.h
    mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/ecp/: ecp_internal_alt.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/: emac_lwip.c emac_stack_lwip.cpp eth_arch.h EthernetInterface.cpp EthernetInterface.h lwip_stack.c lwip_stack.h lwipopts.h ppp_lwip.cpp ppp_lwip.h
    mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    mbed-os/hal/TARGET_FLASH_CMSIS_ALGO/: flash_common_algo.c flash_data.h
    mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    mbed-os/features/mbedtls/targets/: hash_wrappers.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    mbed-os/features/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    mbed-os/features/filesystem/littlefs/: LittleFileSystem.cpp LittleFileSystem.h
    mbed-os/features/lorawan/lorastack/phy/: lora_phy_ds.h LoRaPHY.cpp LoRaPHY.h LoRaPHYAS923.cpp LoRaPHYAS923.h LoRaPHYAU915.cpp LoRaPHYAU915.h LoRaPHYCN470.cpp LoRaPHYCN470.h LoRaPHYCN779.cpp LoRaPHYCN779.h LoRaPHYEU433.cpp LoRaPHYEU433.h LoRaPHYEU868.cpp LoRaPHYEU868.h LoRaPHYIN865.cpp LoRaPHYIN865.h LoRaPHYKR920.cpp LoRaPHYKR920.h LoRaPHYUS915.cpp LoRaPHYUS915.h LoRaPHYUS915Hybrid.cpp LoRaPHYUS915Hybrid.h
    mbed-os/features/lorawan/lorastack/mac/: LoRaMac.cpp LoRaMac.h LoRaMacChannelPlan.cpp LoRaMacChannelPlan.h LoRaMacCommand.cpp LoRaMacCommand.h LoRaMacCrypto.cpp LoRaMacCrypto.h LoRaMacMcps.cpp LoRaMacMcps.h LoRaMacMib.cpp LoRaMacMib.h LoRaMacMlme.cpp LoRaMacMlme.h
    mbed-os/features/lorawan/: LoRaRadio.h LoRaWANBase.h LoRaWANInterface.cpp LoRaWANInterface.h LoRaWANStack.cpp LoRaWANStack.h
    mbed-os/features/lorawan/system/: lorawan_data_structures.h LoRaWANTimer.cpp LoRaWANTimer.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl/: lwip_arc4.c lwip_des.c lwip_md4.c lwip_md5.c lwip_sha1.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/: lwip_auth.c lwip_ccp.c lwip_chap-md5.c lwip_chap-new.c lwip_chap_ms.c lwip_demand.c lwip_eap.c lwip_ecp.c lwip_eui64.c lwip_fsm.c lwip_ipcp.c lwip_ipv6cp.c lwip_lcp.c lwip_magic.c lwip_mppe.c lwip_multilink.c lwip_ppp.c lwip_pppapi.c lwip_pppcrypt.c lwip_pppoe.c lwip_pppol2tp.c lwip_pppos.c lwip_upap.c lwip_utils.c lwip_vj.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/: lwip_random.c lwip_random.h lwip_tcp_isn.c lwip_tcp_isn.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_NUVOTON/TARGET_M480/: lwipopts_conf.h m480_eth.c m480_eth.h m480_netif.c m480_netif.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/device/StdDriver/: m480_acmp.c m480_acmp.h m480_bpwm.c m480_bpwm.h m480_can.c m480_can.h m480_clk.c m480_clk.h m480_crc.c m480_crc.h m480_crypto.c m480_crypto.h m480_dac.c m480_dac.h m480_eadc.c m480_eadc.h m480_ebi.c m480_ebi.h m480_ecap.c m480_ecap.h m480_emac.c m480_emac.h m480_epwm.c m480_epwm.h m480_fmc.c m480_fmc.h m480_gpio.c m480_gpio.h m480_hsotg.h m480_hsusbd.c m480_hsusbd.h m480_i2c.c m480_i2c.h m480_i2s.c m480_i2s.h m480_opa.h m480_otg.h m480_pdma.c m480_pdma.h m480_qei.c m480_qei.h m480_rtc.c m480_rtc.h m480_sc.c m480_sc.h m480_scuart.c m480_scuart.h m480_sdh.c m480_sdh.h m480_spi.c m480_spi.h m480_spim.c m480_spim.h m480_sys.c m480_sys.h m480_timer.c m480_timer.h m480_timer_pwm.c m480_timer_pwm.h m480_uart.c m480_uart.h m480_usbd.c m480_usbd.h m480_usci_i2c.c m480_usci_i2c.h m480_usci_spi.c m480_usci_spi.h m480_usci_uart.c m480_usci_uart.h m480_wdt.c m480_wdt.h m480_wwdt.c m480_wwdt.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    mbed-os/: mbed.h
    mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp SysTimer.h
    mbed-os/targets/TARGET_NUVOTON/: mbed_rtx.h nu_bitutil.h nu_miscutil.c nu_miscutil.h nu_modutil.c nu_modutil.h nu_timer.h
    mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c mbed_rtx_fault_handler.h
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/TARGET_NUMAKER_PFM_M487/: mbedtls_device.h
    mbed-os/features/nvstore/source/: nvstore.cpp nvstore.h
    mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.cpp QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularSIM.cpp QUECTEL_BC95_CellularSIM.h QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularStack.h
    mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.cpp QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularStack.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    mbed-os/features/mbedtls/targets/TARGET_NUVOTON/TARGET_M480/sha/: sha1_alt.c sha1_alt.h sha1_alt_sw.c sha1_alt_sw.h sha256_alt.c sha256_alt.h sha256_alt_sw.c sha256_alt_sw.h sha512_alt.c sha512_alt.h sha512_alt_sw.c sha512_alt_sw.h sha_alt_hw.c sha_alt_hw.h
    mbed-os/targets/TARGET_NUVOTON/TARGET_M480/device/TOOLCHAIN_ARM_STD/: sys.cpp
    mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.cpp TELIT_HE910.h TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.cpp TELIT_HE910_CellularPower.h
    mbed-os/features/cellular/framework/targets/UBLOX/LISA_U/: UBLOX_LISA_U.cpp UBLOX_LISA_U.h UBLOX_LISA_U_CellularNetwork.cpp UBLOX_LISA_U_CellularNetwork.h UBLOX_LISA_U_CellularPower.cpp UBLOX_LISA_U_CellularPower.h
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
  group NuMaker-mbed-OS-Core-RTOS-Basic
    ./: main.cpp mbed_config.h
